# Keil uVision project bsp_ir_oled_new.uvprojx, settings and files
target IR_OLED (6070000::V6.7::.\ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IIC_SOFT +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;\..\..\source\ti\driverlib\m0p\sysctl;..\BSP\OLED;..\..\eight_ir_oled_new;..\BSP\Motor;..\BSP;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c main.c
    ./: startup_mspm0g350x_uvision.s
    ../BSP/: AllHeader.h
  group BSP
    ../BSP/: delay.c usart0.c bsp_beep_led.c bsp_timer.c bsp_ir_eight.c
    ../BSP/OLED/: oled.c
    ../BSP/Motor/: bsp_encoder.c bsp_motor.c
  group APP
    ../APP/: app_motor.c bsp_PID_motor.c app_irtracking_eight.c
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
